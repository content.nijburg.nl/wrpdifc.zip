Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 2dce184c-54da-4de0-a91c-800ae8aab741, NumberOfSaves: 35]
File name: Project Number
Time: 2024-01-25T11:42:45+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, OutPort_2200888_1
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: NLRS_57_AIR_UN_wall_diffuser_WRPD_Return_Solid_Air:600, NLRS_57_AIR_UN_wall_diffuser_WRPD_Return_Solid_Air:600:2200888
In: Default
Type - Description: Perforated return grill for use in walls, Type WRPDO; PredefinedType: DIFFUSER; Material: Sendzimir verzinkt, RAL9010
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_wall_diffuser_WRPD_Return_Solid_Air; SACS_Base_Index: 1000962
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - SACS_Plenum_C: 570 mm; SACS_Plenum_D: 248 mm; SACS_Plenum_E: 305 mm; SACS_Plenum_K: 169 mm; SACS_Plenum_L: 250 mm; SACS_Plenum_P: 468 mm
Type - General - Lookup_Article_Codes: WRPDO_Article_Codes; Lookup_Article_Data: WRPDO_Article_Data; Lookup_Article_Names: WRPDO_Article_Names; Lookup_Grill_Factors: WRPDO_Interpolation_Factors; SACS_Revised_ by: J. Feeke; SACS_Revision_Date: 2019-11-14; SACS_Revision_Number: 2.0
Type - Identity Data - Assembly Code: 57.00; Cost: 0; Description: Perforated return grill for use in walls, Type WRPDO; Manufacturer: Solid Air Climate Solutions; Model: WRPDO; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 2019-11-14; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 2.0; NLRS_C_description: Perforated return grill for use in walls, Type WRPDO; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Type Comments: Please make sure flow is set to m3/h!; Type Name: 600; URL: https://solid-air.nl/producten/roosters/wand-en-doorvoerroosters/wandroosters/wtpd-wrpd
Type - Materials and Finishes - SACS_Plenum_Material: Sendzimir verzinkt
Type - Mechanical - Flow - Max Flow: 150 dm3/s; Min Flow: 50 dm3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.00 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 600; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_wall_diffuser_WRPD_Return_Solid_Air; Family and Type: NLRS_57_AIR_UN_wall_diffuser_WRPD_Return_Solid_Air: 600; Type: 600; Type Id: 2200862
Model Properties - (0) Connector Back (Default): no; (1) Connector Left: no; (2) Connector Right: yes; Connection side (0-2): 2; SACS_Color_Ral: yes; SACS_Lined_Plenum: yes; SACS_Standard_Color: yes; Wall Thickness (Standard = 110): 110 mm
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 1.38325 m2; NLRS_M_c01_diameter: 250 mm; SACS_Plenum_Length: 468 mm; Volume: 0.00337873 m3
Identity Data - Mark: 8713; NLRS_C_materiaal_kleur: Ral 9010; NLRS_C_model: WRPDOK 600; SACS_Article_Code: 8301000982; SACS_Gross_Cost: 214; SACS_Price_Version: 201906
Materials and Finishes - SACS_Color: Ral 9010; SACS_Face_Material: RAL9010 Perforated; SACS_Flange_Material: RAL9010; SACS_Lining_Material: Armaflex; SACS_Lining_Thickness: 12 mm
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_DbA: 28; SACS_Max_Ploss: 35 Pa; System Classification: Return Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Lp_dBA: 0
Phasing - Phase Created: New Construction
Text - SACS_Warning_Text_Flow: Flow out of default specification!
Visibility - SACS_Arrows_and_Throw_Enabled: yes; SACS_Warning_Disable: yes
